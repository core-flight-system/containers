# Start with the basic minimal image from the poky upstream
# Although the name suggests minimalism, this base image actually includes quite a bit
require recipes-core/images/core-image-minimal.bb
require images/core-image-cfecfs.inc


