# This recipe just has some simple overrides for files in the base-files package

FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
